
/******************************************************************************
*  File           :  buf1.c
*  Version        :  1
*  Last Changes   :  2019-04-29 19:56:38
******************************************************************************/

/******************************************************************************
*  Include Files
******************************************************************************/

#include "typ.h"
#include "buf1.h"

/******************************************************************************
*  Local Constants
******************************************************************************/

/******************************************************************************
*  Local Type Definitions
******************************************************************************/

/******************************************************************************
*  Local Variables
******************************************************************************/

TUINT8 buf1_au8SndBuf[BUF1_SNDLEN + 1];
TUINT16 buf1_u16SndBuf_Head = 0;
TUINT16 buf1_u16SndBuf_Tail = 0;

TUINT8 buf1_au8RecBuf[BUF1_RECLEN + 1];
TUINT16 buf1_u16RecBuf_Head = 0;
TUINT16 buf1_u16RecBuf_Tail = 0;

/******************************************************************************
*  Global Variables
******************************************************************************/

TUINT8 BUF1_u8Buf;

/******************************************************************************
*  Local Function Prototypes
******************************************************************************/

/******************************************************************************
*  Local Functions
******************************************************************************/

/******************************************************************************
*  Global Functions
******************************************************************************/

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

void BUF1_SndBuf_Put (TUINT8 u8Data)
{
  buf1_au8SndBuf[buf1_u16SndBuf_Tail++] = u8Data;
  if (buf1_u16SndBuf_Tail > BUF1_SNDLEN) buf1_u16SndBuf_Tail = 0;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF1_u8SndBuf_Get (void)
{
  TUINT8 u8Data = buf1_au8SndBuf[buf1_u16SndBuf_Head++];
  if (buf1_u16SndBuf_Head > BUF1_SNDLEN) buf1_u16SndBuf_Head = 0;
  return u8Data;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF1_u8SndBuf_Empty (void)
{
  return buf1_u16SndBuf_Head == buf1_u16SndBuf_Tail;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

void BUF1_RecBuf_Put (TUINT8 u8Data)
{
  buf1_au8RecBuf[buf1_u16RecBuf_Tail++] = u8Data;
  if (buf1_u16RecBuf_Tail > BUF1_RECLEN) buf1_u16RecBuf_Tail = 0;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF1_u8RecBuf_Get (void)
{
  TUINT8 u8Data = buf1_au8RecBuf[buf1_u16RecBuf_Head++];
  if (buf1_u16RecBuf_Head > BUF1_RECLEN) buf1_u16RecBuf_Head = 0;
  return u8Data;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF1_u8RecBuf_Empty (void)
{
  return buf1_u16RecBuf_Head == buf1_u16RecBuf_Tail;
}


/******************************************************************************
*  Changes        :  
*                    
*                    
*                    
******************************************************************************/

/******************************************************************************
*  END OF FILE    :  buf1.h
******************************************************************************/

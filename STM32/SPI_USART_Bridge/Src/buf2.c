
/******************************************************************************
*  File           :  buf2.c
*  Version        :  1
*  Last Changes   :  2019-04-29 19:56:38
******************************************************************************/

/******************************************************************************
*  Include Files
******************************************************************************/

#include "typ.h"
#include "buf2.h"

/******************************************************************************
*  Local Constants
******************************************************************************/

/******************************************************************************
*  Local Type Definitions
******************************************************************************/

/******************************************************************************
*  Local Variables
******************************************************************************/

TUINT8 buf2_au8SndBuf[BUF2_SNDLEN + 1];
TUINT16 buf2_u16SndBuf_Head = 0;
TUINT16 buf2_u16SndBuf_Tail = 0;

TUINT8 buf2_au8RecBuf[BUF2_RECLEN + 1];
TUINT16 buf2_u16RecBuf_Head = 0;
TUINT16 buf2_u16RecBuf_Tail = 0;


/******************************************************************************
*  Global Variables
******************************************************************************/

TUINT8 BUF2_u8Buf;

/******************************************************************************
*  Local Function Prototypes
******************************************************************************/

/******************************************************************************
*  Local Functions
******************************************************************************/

/******************************************************************************
*  Global Functions
******************************************************************************/

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

void BUF2_SndBuf_Put (TUINT8 u8Data)
{
  buf2_au8SndBuf[buf2_u16SndBuf_Tail++] = u8Data;
  if (buf2_u16SndBuf_Tail > BUF2_SNDLEN) buf2_u16SndBuf_Tail = 0;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF2_u8SndBuf_Get (void)
{
  TUINT8 u8Data = buf2_au8SndBuf[buf2_u16SndBuf_Head++];
  if (buf2_u16SndBuf_Head > BUF2_SNDLEN) buf2_u16SndBuf_Head = 0;
  return u8Data;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF2_u8SndBuf_Empty (void)
{
  return buf2_u16SndBuf_Head == buf2_u16SndBuf_Tail;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

void BUF2_RecBuf_Put (TUINT8 u8Data)
{
  buf2_au8RecBuf[buf2_u16RecBuf_Tail++] = u8Data;
  if (buf2_u16RecBuf_Tail > BUF2_RECLEN) buf2_u16RecBuf_Tail = 0;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF2_u8RecBuf_Get (void)
{
  TUINT8 u8Data = buf2_au8RecBuf[buf2_u16RecBuf_Head++];
  if (buf2_u16RecBuf_Head > BUF2_RECLEN) buf2_u16RecBuf_Head = 0;
  return u8Data;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF2_u8RecBuf_Empty (void)
{
  return buf2_u16RecBuf_Head == buf2_u16RecBuf_Tail;
}


/******************************************************************************
*  Changes        :  
*                    
*                    
*                    
******************************************************************************/

/******************************************************************************
*  END OF FILE    :  buf2.h
******************************************************************************/

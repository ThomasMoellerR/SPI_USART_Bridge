
/******************************************************************************
*  File           :  buf3.c
*  Version        :  1
*  Last Changes   :  2019-04-29 19:56:38
******************************************************************************/

/******************************************************************************
*  Include Files
******************************************************************************/

#include "typ.h"
#include "buf3.h"

/******************************************************************************
*  Local Constants
******************************************************************************/

/******************************************************************************
*  Local Type Definitions
******************************************************************************/

/******************************************************************************
*  Local Variables
******************************************************************************/

TUINT8 buf3_au8SndBuf[BUF3_SNDLEN + 1];
TUINT16 buf3_u16SndBuf_Head = 0;
TUINT16 buf3_u16SndBuf_Tail = 0;

TUINT8 buf3_au8RecBuf[BUF3_RECLEN + 1];
TUINT16 buf3_u16RecBuf_Head = 0;
TUINT16 buf3_u16RecBuf_Tail = 0;

/******************************************************************************
*  Global Variables
******************************************************************************/

TUINT8 BUF3_u8Buf;

/******************************************************************************
*  Local Function Prototypes
******************************************************************************/

/******************************************************************************
*  Local Functions
******************************************************************************/

/******************************************************************************
*  Global Functions
******************************************************************************/

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

void BUF3_SndBuf_Put (TUINT8 u8Data)
{
  buf3_au8SndBuf[buf3_u16SndBuf_Tail++] = u8Data;
  if (buf3_u16SndBuf_Tail > BUF3_SNDLEN) buf3_u16SndBuf_Tail = 0;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF3_u8SndBuf_Get (void)
{
  TUINT8 u8Data = buf3_au8SndBuf[buf3_u16SndBuf_Head++];
  if (buf3_u16SndBuf_Head > BUF3_SNDLEN) buf3_u16SndBuf_Head = 0;
  return u8Data;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF3_u8SndBuf_Empty (void)
{
  return buf3_u16SndBuf_Head == buf3_u16SndBuf_Tail;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

void BUF3_RecBuf_Put (TUINT8 u8Data)
{
  buf3_au8RecBuf[buf3_u16RecBuf_Tail++] = u8Data;
  if (buf3_u16RecBuf_Tail > BUF3_RECLEN) buf3_u16RecBuf_Tail = 0;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF3_u8RecBuf_Get (void)
{
  TUINT8 u8Data = buf3_au8RecBuf[buf3_u16RecBuf_Head++];
  if (buf3_u16RecBuf_Head > BUF3_RECLEN) buf3_u16RecBuf_Head = 0;
  return u8Data;
}

/******************************************************************************
*  Function Name  :
*  Description    :
*  Parameter(s)   :
*  Return Value   :
******************************************************************************/

TUINT8 BUF3_u8RecBuf_Empty (void)
{
  return buf3_u16RecBuf_Head == buf3_u16RecBuf_Tail;
}


/******************************************************************************
*  Changes        :  
*                    
*                    
*                    
******************************************************************************/

/******************************************************************************
*  END OF FILE    :  buf3.h
******************************************************************************/
